Commit message: IQL update

File: urdf/camera.urdf (robot description, URDF)
Before this commit: robot camera_cube, 1 links, 0 joints
Links:
- link camera_cube_body: mass 0.1 -> 100.0
